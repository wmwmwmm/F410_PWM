<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\N_F410_LED.ewp</path>
  </project>
  <batchBuild />
</workspace>
